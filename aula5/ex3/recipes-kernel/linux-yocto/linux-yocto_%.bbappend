COMPATIBLE_MACHINE:append = "|treinamento"